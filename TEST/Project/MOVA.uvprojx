# Keil uVision project MOVA.uvprojx, settings and files
target MOVA (6240000::V6.24::ARMCLANG)
  device: GD32E235CB GigaDevice
  pack: GigaDevice.GD32E23x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0004000) IROM(0x08000000,0x0020000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: MOVA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32E235
  c include: ..\User;..\User\core;..\User\drivers;..\User\app;..\Libraries\CMSIS\GD\GD32E23x\Include;..\Libraries\GD32E23x_standard_peripheral\Include;..\Libraries\CMSIS;D:\Software\Keil\ARM\ARMCLANG\include;..\User\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group START
    ../Libraries/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group FWLIB
    ../Libraries/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group USER
    ../User/core/: gd32e23x_it.c systick.c
    ../User/: main.c
    ../User/drivers/: fan.c pump.c zero.c uart.c triac.c Pwr12.c
    ../User/app/: disp.c
  group CMSIS
    ../Libraries/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
software components: CMSIS:CORE 6.2.0
